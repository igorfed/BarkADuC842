# Keil uVision project bark.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC824 Analog Devices
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(12000000) DPX
  output: bark +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source
    ./: main.c uart.c text.c debug.c bark.c funct.c
